options:
  parameters:
    generate_options: qt_gui
    id: gmrs_online
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(samp_rate/dec1/dec2)
  states: {}
- name: dec1
  id: variable
  parameters:
    value: '35'
  states: {}
- name: dec2
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq_mhz
  id: variable_qtgui_range
  parameters:
    label: Frequency (MHz)
    start: '30'
    step: '0.02'
    stop: '6000'
    value: '462.56381'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    label: Analog Gain (dB)
    start: '-30'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_msps * 1e6
  states: {}
- name: samp_rate_msps
  id: variable_qtgui_entry
  parameters:
    label: Sample Rate (MSPS)
    type: real
    value: '4.48'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    label: Threshold (dB)
    start: '-100'
    step: '1'
    stop: '100'
    value: '-50'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: int(samp_rate / dec1)
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-2'
    gate: 'True'
    ramp: '0'
    threshold: thresh
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      # TODO: Import existing ASR code here (from transcribe_online.py)


      class blk(gr.sync_block):  # sinks are derived from sync blocks

          def __init__(self, sample_rate=16e3):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded ASR Block',  # will show up in GRC
                  in_sig=[np.float32],  # input is a float32 stream
                  out_sig=[]  # no output port, this is a sink
              )
              # Allow user of block to pass in the sample rate (since this is set in
              # the flowgraph itself).
              self.sample_rate = sample_rate
              # TODO: Initialization code from transcribe_online goes here (e.g.,
              # create a SpeechInference object using the sample_rate).

          def work(self, input_items, output_items):
              # TODO: Run the model here. Return the number of samples to GNU Radio
              # that were processed. There is likely some math involved here with the
              # windowing parameters.
              # TODO: Print any words the model detects.
              return 0  # number of float32 samples processed
    sample_rate: audio_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: dec1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate / dec1
    ctrlpanel: 'True'
    fc: freq_mhz*1e6
    fftsize: '1024'
    grid: 'True'
    legend: 'False'
    name: '"LPF FFT"'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    antenna0: RX1
    center_freq0: freq_mhz*1e6
    dc_removal0: 'False'
    driver: SoapyAIRT
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', epy_block_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
