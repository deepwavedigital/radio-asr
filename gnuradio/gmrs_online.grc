options:
  parameters:
    generate_options: qt_gui
    id: gmrs_online
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(samp_rate/dec1/dec2)
  states: {}
- name: dec1
  id: variable
  parameters:
    value: '35'
  states: {}
- name: dec2
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq_mhz
  id: variable_qtgui_range
  parameters:
    label: Frequency (MHz)
    start: '30'
    step: '0.02'
    stop: '6000'
    value: '462.56381'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    label: Analog Gain (dB)
    start: '-30'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_msps * 1e6
  states: {}
- name: samp_rate_msps
  id: variable_qtgui_entry
  parameters:
    label: Sample Rate (MSPS)
    type: real
    value: '4.48'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    label: Threshold (dB)
    start: '-100'
    step: '1'
    stop: '100'
    value: '-50'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: int(samp_rate / dec1)
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-2'
    gate: 'True'
    ramp: '0'
    threshold: thresh
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nfrom radio_asr.online import SpeechInference\n\nclass blk(gr.sync_block):  # sinks are derived from sync blocks\n\n    def __init__(self, sample_rate=16e3):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded ASR Block',  # will show up in GRC\n            in_sig=[np.float32],  # input is a float32 stream\n            out_sig=[]  # no output port, this is a sink\n        )\n        # Allow user of block to pass in the sample rate (since this is set in\n        # the flowgraph itself).\n        self.sample_rate = sample_rate\n        self.engine = SpeechInference(sample_rate=sample_rate)\n\n        if sample_rate != 16000.0:\n            raise ValueError(\"Only 16kHz sample rates are supported by this model\")\n        \n    def work(self, input_items, output_items):\n        assert len(input_items) >= speech.n_frame_len\n        text = self.engine.transcribe(\n            input_items[:self.engine.n_frame_len])\n        print(text.strip())\n        return self.engine.n_frame_len  # number of float32 samples processed\n\n"
    sample_rate: audio_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: dec1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate / dec1
    ctrlpanel: 'True'
    fc: freq_mhz*1e6
    fftsize: '1024'
    grid: 'True'
    legend: 'False'
    name: '"LPF FFT"'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    antenna0: RX1
    center_freq0: freq_mhz*1e6
    dc_removal0: 'False'
    driver: SoapyAIRT
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', epy_block_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
