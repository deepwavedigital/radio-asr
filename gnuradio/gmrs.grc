options:
  parameters:
    generate_options: qt_gui
    id: gmrs
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(samp_rate/dec1/dec2)
  states: {}
- name: dec1
  id: variable
  parameters:
    value: '35'
  states: {}
- name: dec2
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq_mhz
  id: variable_qtgui_range
  parameters:
    label: Frequency (MHz)
    start: '30'
    step: '0.02'
    stop: '6000'
    value: '462.56381'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    label: Analog Gain (dB)
    start: '-30'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_msps * 1e6
  states: {}
- name: samp_rate_msps
  id: variable_qtgui_entry
  parameters:
    label: Sample Rate (MSPS)
    type: real
    value: '4.48'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    label: Threshold (dB)
    start: '-100'
    step: '1'
    stop: '100'
    value: '-50'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: int(samp_rate / dec1)
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-2'
    gate: 'True'
    ramp: '0'
    threshold: thresh
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: gmrs.wav
    format: FORMAT_WAV
    samp_rate: audio_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: dec1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate / dec1
    ctrlpanel: 'True'
    fc: freq_mhz*1e6
    fftsize: '1024'
    grid: 'True'
    legend: 'False'
    name: '"LPF FFT"'
    type: complex
  states: {}
- name: soapy_airt_source_0
  id: soapy_airt_source
  parameters:
    agc: 'True'
    center_freq: freq_mhz*1e6
    dev_args: ''
    gain0: '0'
    gain1: '0'
    nchan: '1'
    samp_rate0: samp_rate
    samp_rate1: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://10.1.2.92:50001
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_nbfm_rx_0, '0', blocks_wavfile_sink_0, '0']
- [analog_nbfm_rx_0, '0', zeromq_pub_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_airt_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
