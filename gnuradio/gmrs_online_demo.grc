options:
  parameters:
    generate_options: qt_gui
    id: gmrs_online_demo
    output_language: python
    qt_qss_theme: /export/conda-environments/nemo-1.3.0/share/gnuradio/themes/dark.qss
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(samp_rate/dec1/dec2)
  states: {}
- name: dec1
  id: variable
  parameters:
    value: '35'
  states: {}
- name: dec2
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq_mhz
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '["1", "2", "3", "4", "5", "6", "7"]'
    num_opts: '0'
    options: '[462.5625, 462.5875, 462.6125, 462.6375, 462.6625, 462.6875, 462.7125]'
    orient: Qt.QHBoxLayout
    type: real
    value: '462.5625'
    widget: radio_buttons
  states: {state: disabled}
- name: freq_mhz
  id: variable
  parameters:
    value: '462.5625'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4.48e6
  states: {}
- name: thresh
  id: variable_qtgui_entry
  parameters:
    label: Threshold (dB)
    type: real
    value: '-30'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: int(samp_rate / dec1)
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-2'
    gate: 'False'
    ramp: '0'
    threshold: thresh
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import datetime
      import time

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # sinks are derived from sync blocks

          def __init__(self, sample_rate=16e3):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded ASR Block',  # will show up in GRC
                  in_sig=[np.float32],  # input is a float32 stream
                  out_sig=[]  # no output port, this is a sink
              )

              self.benchmark = False  # For performance debugging
              # Allow user of block to pass in the sample rate (since this is set in
              # the flowgraph itself).
              self.sample_rate = sample_rate
              self.engine = None
              self.new_line = False
              if sample_rate != 16000.0:
                  raise ValueError("Only 16kHz sample rates are supported by this model")

          def start(self):
              from radio_asr.online import SpeechInference
              if self.engine:
                  del self.engine
              print("Creating and initializing speech inference model.")
              self.engine = SpeechInference(sample_rate=self.sample_rate)
              self.buffer = np.zeros(self.engine.n_frame_len)
              self.pos = 0
              self.buf_duration = self.engine.n_frame_len / self.sample_rate
              print("Finished initializing speech inference model.")
              return True
                  
          def work(self, input_items, output_items):
              data = input_items[0]
              n_samples = len(data)
              if self.pos + n_samples < self.engine.n_frame_len: # Buffer data
                  self.buffer[self.pos:self.pos+n_samples] = data
                  self.pos += n_samples
                  return n_samples
              else:
                  n_processed = self.engine.n_frame_len - self.pos
                  self.buffer[self.pos:] = data[:n_processed]

                  # Measure transcription time
                  t_start = time.time()
                  text = self.engine.transcribe(self.buffer)
                  t_end = time.time()
                  t_duration = t_end - t_start
                  ratio = self.buf_duration / t_duration
                  
                  text = text.strip()

                  if len(text):
                      self.new_line = False
                      print(" " + text, end='', flush=True)
                  elif not self.new_line:
                      print("", end='\n', flush=True)
                      self.new_line = True

                  if self.benchmark:                
                      now = datetime.datetime.now()
                      print(f"[{now}] Transcribed {self.buf_duration:.2f}sec in {t_duration:.2f}sec ({ratio:.2f}x): '{text}'")

                  self.pos = 0
                  return n_processed
    sample_rate: audio_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: dec1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    legend: 'False'
    name: '"Audio Signal"'
    size: '16384'
    srate: audio_rate
    type: float
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    antenna0: RX1
    center_freq0: freq_mhz*1e6
    dc_removal0: 'False'
    driver: SoapyAIRT
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', dc_blocker_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [dc_blocker_xx_0, '0', epy_block_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [soapy_custom_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
